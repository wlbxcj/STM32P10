# IAR project kf322_monitor.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  ICCARM.CCDefines: STM32F10X_HD
  ICCARM.CCIncludePath2: ..\src\inc; ..\src\inc\libinc; ..\src\inc\pn512; ..\src\source\inc; ..\src\l2\inc; ..\src\driver\com; ..\src\driver\picc_as3911\picc; ..\src\driver\picc_as3911\EMV; ..\src\driver\ts\; ..\src\driver\lcd\; ..\src\driver\dll; ..\src\driver\pci; ..\src\driver\encrypt; ..\src\driver\usb; ..\src\library\STM32_USB-FS-Device_Driver\inc; C:\Program Files\tools\NOV30\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: v10p_monitor.bin
  ILINK.IlinkOutputFile: v10p_monitor.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkAdditionalLibs: ..\src\library\lib_entry_001.a; ..\src\library\lib_qpboc_001.a; ..\projectlib\Debug\Exe\v10plib043.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  group project
    ./: stm32f10x_flash.icf
  group src/app
    ../src/app/: Def.h EmvLib.h Func.h global.h OperCmd.h PED.c PED.h qpboc.h
  group src/driver
    ../src/driver/: Buzzer.c calendar.c cortexm3_macro.s FlashOperate.c KF701DH.c main.c pcimain.c RF1356.C smartcard.c SysTimer.c Toolkit.c UartProtocol.c
  group src/driver/com
    ../src/driver/com/: comm.c comm.h
  group src/driver/dll
    ../src/driver/dll/: dll.c dll.h
  group src/driver/download
    ../src/driver/download/: download.c
  group src/driver/encrypt
    ../src/driver/encrypt/: des.c des.h global.h rsa.c rsa.h
  group src/driver/file
    ../src/driver/file/: file.c
  group src/driver/kb
    ../src/driver/kb/: kb.c kb.h
  group src/driver/lcd
    ../src/driver/lcd/: lcd.c lcd.h
  group src/driver/pci
    ../src/driver/pci/: dukpt.c dukpt.h PCI.c pci.h
  group src/driver/picc
    ../src/driver/picc/: picc.h picc_stm32f.h
  group src/driver/pn512
    ../src/driver/pn512/: Mifre.c Mifre.h Mifre_TmDef.h MifreCmd.c MifreCmd.h MifreHal.c MifreHal.h MifreInnerTest.c MifreTest.c
  group src/driver/smartcard
    ../src/driver/smartcard/: emv_hard.c icc.c icc.h
  group src/driver/test
    ../src/driver/test/: maintest.c
  group src/driver/voice
    ../src/driver/voice/: voice.c
  group src/inc
    ../src/inc/: ASCII8X8.h base.h Buzzer.h calendar.h Comm.h Data.h DataFlash.h Declare.h def.h Display.h FlashOperate.h FunctionList.h I2C.H I2CEEPROM.h I2CRTC.h ICCmd.h ISO14443.h kf701dh.h KF701DV.h Mem.h phcsBflHw1Reg.h phcsBflStatus.h RF1356.h smartcard.h SPIFlash.h TaxBox.h Toolkit.h UARTCom.h UartProtocol.h UARTSC.h USBCom.h vosapi.h
    ../src/driver/: pcicmd.h
  group src/inc/libinc
    ../src/inc/libinc/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_conf.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_it.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_tim1.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h
  group src/l2/inc
    ../src/l2/inc/: contactless_common.h emvcore.h emvif.h entrycore.h fcntl.h misc.h port.h qpboccore.h rsaapp.h scc-support.h stat.h struct.h var.h
  group src/l2/src
    ../src/l2/src/: crc16.c emvif.c emvproc.c func.c PosPiccPublic.c var.c
  group src/l2/src/port
    ../src/l2/src/: appdes.c
    ../src/l2/src/port/: portdisp.c portfile.c porttime.c
  group src/library
    ../src/library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_tim1.c stm32f10x_usart.c stm32f10x_vector.c stm32f10x_wwdg.c
