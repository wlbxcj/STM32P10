# IAR project Backup (2) of kf322_monitor.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  ICCARM.CCIncludePath2: ..\src\inc; ..\src\inc\libinc; ..\src\l2\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: kf322_monitor.hex
  ILINK.IlinkOutputFile: kf322_monitor.bin
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkAdditionalLibs: ..\src\library\EntryQpboc.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkOutputFile: kf322_monitor.out
  group project
    ./: stm32f10x_flash.icf
  group src/driver
    ../src/driver/: Buzzer.c calendar.c Comm.c cortexm3_macro.s Display.c FlashOperate.c kb.c KF701DH.c main.c RF1356.C smartcard.c SysTimer.c Toolkit.c UARTCom.c UartProtocol.c
  group src/driver/pn512
    ../src/driver/pn512/: Mifre.c Mifre.h Mifre_TmDef.h MifreCmd.c MifreCmd.h MifreHal.c MifreHal.h MifreInnerTest.c MifreTest.c
  group src/inc
    ../src/inc/: ASCII8X8.H Buzzer.h calendar.h Comm.h Data.h DataFlash.h Declare.h def.h Display.h FlashOperate.h I2C.H I2CEEPROM.h I2CRTC.h ICCmd.h ISO14443.h KF701DH.h KF701DV.h Mem.h phcsBflHw1Reg.h phcsBflStatus.h RF1356.h smartcard.h SPIFlash.h TaxBox.h Toolkit.h UARTCom.h UartProtocol.h UARTSC.h USBCom.h
  group src/inc/libinc
    ../src/inc/libinc/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_conf.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_it.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_tim1.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h
  group src/l2/inc
    ../src/l2/inc/: contactless_common.h emvcore.h emvif.h entrycore.h rsaapp.h var.h
  group src/l2/src
    ../src/l2/src/: crc16.c des.c emvif.c emvproc.c func.c PosPiccPublic.c var.c
  group src/l2/src/port
    ../src/l2/src/port/: portdisp.c portfile.c porttime.c
  group src/library
    ../src/library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_tim1.c stm32f10x_usart.c stm32f10x_vector.c stm32f10x_wwdg.c
