# IAR project evaluator7t.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  ICCARM.CCDefines: STM32F10X_HD
  ICCARM.CCIncludePath2: ..\src\inc; ..\src\inc\libinc; ..\src\inc\pn512; ..\src\source\inc; ..\src\l2\inc; ..\src\driver\com; ..\src\driver\picc_as3911\picc; ..\src\driver\picc_as3911\EMV; ..\src\driver\ts\; ..\src\driver\lcd\; ..\src\driver\dll; ..\src\driver\pci; ..\src\driver\encrypt; ..\src\driver\usb\; ..\src\library\STM32_USB-FS-Device_Driver\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: evaluator7t.srec
  ILINK.IlinkOutputFile: evaluator7t.out
  ILINK.IlinkIcfFile: evaluator7t.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCOptStrategy: 1
  group src/driver
    ../src/driver/: Buzzer.c calendar.c cortexm3_macro.s FlashOperate.c KF701DH.c RF1356.C smartcard.c SysTimer.c Toolkit.c UartProtocol.c
    ../src/driver/com/: comm.c
  group src/driver/com
    ../src/driver/com/: comm.h
  group src/driver/dll
    ../src/driver/dll/: dll.c dll.h
  group src/driver/download
    ../src/driver/download/: download.c download.h
  group src/driver/encrypt
    ../src/driver/encrypt/: des.c des.h global.h rsa.c rsa.h sm.c
  group src/driver/file
    ../src/driver/file/: file.c
  group src/driver/kb
    ../src/driver/kb/: kb.c kb.h
  group src/driver/lcd
    ../src/driver/lcd/: lcd.c lcd.h
  group src/driver/pci
    ../src/driver/pci/: dukpt.c dukpt.h PCI.c pci.h
  group src/driver/picc_as3911/AS3911
    ../src/driver/picc_as3911/AS3911/: as3911.h as3911_com.c as3911_com.h as3911_def.h as3911_errno.h as3911_gain_adjustment.c as3911_gain_adjustment.h as3911_interrupt.c as3911_interrupt.h as3911_io.c as3911_io.h as3911_irq.h as3911_modulation_adjustment.c as3911_modulation_adjustment.h
  group src/driver/picc_as3911/EMV
    ../src/driver/picc_as3911/EMV/: emv_digital.c emv_digital.h emv_display.c emv_display.h emv_doc.h emv_error_codes.h emv_hal.c emv_hal.h emv_layer4.c emv_layer4.h emv_main.c emv_main.h emv_picc.c emv_picc.h emv_poll.c emv_poll.h emv_prelayer4.c emv_prelayer4.h emv_prevalidation.c emv_prevalidation.h emv_response_buffer.c emv_response_buffer.h emv_standard.h emv_typeA.c emv_typeA.h emv_typeB.c emv_typeB.h emv_typeX.h
  group src/driver/picc_as3911/picc
    ../src/driver/picc_as3911/picc/: picc.c picc.h picc_errno.h
  group src/driver/pn512
    ../src/driver/pn512/: Mifre.c Mifre.h Mifre_TmDef.h MifreCmd.c MifreCmd.h MifreHal.c MifreHal.h MifreInnerTest.c MifreTest.c
  group src/driver/smartcard
    ../src/driver/smartcard/: emv_hard.c emv_hard.h icc.c icc.h
  group src/driver/ts
    ../src/driver/ts/: calibration.c calibration.h tsc2046.c tsc2046.h
  group src/driver/USB
    ../src/driver/usb/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group src/driver/voice
    ../src/driver/voice/: voice.c
  group src/inc
    ../src/inc/: ASCII8X8.h base.h Buzzer.h calendar.h crc16.h Data.h DataFlash.h Declare.h def.h Display.h FLASHOPERATE.h FunctionList.h I2C.H I2CEEPROM.h I2CRTC.h ICCmd.h ISO14443.h kb.h kf701dh.h KF701DV.h Mem.h phcsBflHw1Reg.h phcsBflStatus.h PosPiccPublic.h RF1356.h smartcard.h SPIFlash.h SysTimer.h TaxBox.h Toolkit.h UARTCom.h UartProtocol.h UARTSC.h usb_desc.h USBCom.h USBHost.h vosapi.h
  group src/inc/libinc
    ../src/inc/libinc/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_conf.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_it.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_tim1.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h
  group src/L2/src
    ../src/l2/src/port/: porttime.c
  group src/library
    ../src/library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_tim1.c stm32f10x_usart.c stm32f10x_vector.c stm32f10x_wwdg.c
  group src/STM32_USB-FS-Device_Driver
    ../src/library/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
