# IAR project Backup of kf322_monitor.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl7mptnnl8f.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCIncludePath2: ..\src\inc; ..\src\inc\libinc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnkarm_flash.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.r79
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group project
    ./: lnkarm_flash.xcl
  group src/driver
    ../src/driver/: Buzzer.c calendar.c Comm.c cortexm3_macro.s Display.c FlashOperate.c KF701DH.c main.c MifreInnerTest.c RF1356.C SysTimer.c Toolkit.c UARTCom.c UartProtocol.c
  group src/driver/rc531
    ../src/driver/rc531/: Mifre.c Mifre.h Mifre_TmDef.h MifreCmd.c MifreCmd.h MifreHal.c MifreHal.h MifreTest.c
  group src/inc
    ../src/inc/: ASCII8X8.H Buzzer.h calendar.h Comm.h Data.h DataFlash.h Declare.h def.h Display.h FlashOperate.h I2C.H I2CEEPROM.h I2CRTC.h ICCmd.h ISO14443.h KF701DH.h KF701DV.h Mem.h phcsBflHw1Reg.h phcsBflStatus.h RF1356.h SPIFlash.h TaxBox.h Toolkit.h UARTCom.h UARTSC.h USBCom.h
  group src/inc/libinc
    ../src/inc/libinc/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_conf.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_it.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_tim1.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h
  group src/library
    ../src/library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_tim1.c stm32f10x_usart.c stm32f10x_vector.c stm32f10x_wwdg.c
